# IAR project msa_msp430.ewp, settings and files
configuration Normal (MSP430, debug)
  General.OGChipSelectMenu: MSP430F5438A MSP430F5438A
  General.GStackSize2: 256
  General.GHeapSize2: 256
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: HAL_DMA=FALSE; HAL_UART=FALSE; POWER_SAVING; xFEATURE_MAC_SECURITY; FEATURE_GREEN_POWER; FEATURE_ENHANCED_BEACON
  ICC430.CCDiagSuppress: Pe826, Pe236
  ICC430.newCCIncludePaths: ..\..\Application; ..\..\..\..\..\Components\services\saddr; ..\..\..\..\..\Components\services\sdata; ..\..\..\..\..\Components\osal\include; ..\..\..\..\..\Components\osal\mcu\msp430; ..\..\..\..\..\Components\mt; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\hal\target\MSP5438CC2520; ..\..\..\..\..\Components\mac\include; ..\..\..\..\..\Components\mac\high_level; ..\..\..\..\..\Components\mac\low_level\srf04; ..\..\..\..\..\Components\mac\low_level\srf04\dual_chip; ..\..\..\common\msp430\
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5438A.xcl
  XLINK.XlinkStackSize: 1
configuration Secure (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: HAL_DMA=FALSE; HAL_UART=FALSE; POWER_SAVING; FEATURE_MAC_SECURITY; FEATURE_GREEN_POWER; FEATURE_ENHANCED_BEACON
  ICC430.newCCIncludePaths: ..\..\Application; ..\..\..\..\..\Components\services\saddr; ..\..\..\..\..\Components\services\sdata; ..\..\..\..\..\Components\osal\include; ..\..\..\..\..\Components\osal\mcu\msp430; ..\..\..\..\..\Components\services\aes; ..\..\..\..\..\Components\mt; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\hal\target\MSP5438CC2520; ..\..\..\..\..\Components\mac\include; ..\..\..\..\..\Components\mac\high_level; ..\..\..\..\..\Components\mac\low_level\srf04; ..\..\..\..\..\Components\mac\low_level\srf04\dual_chip; ..\..\..\common\msp430\
  group Application
    ../../Application/: msa.c msa.h msa_Main.c msa_Osal.c
  group HAL/Common
    ../../../../../Components/hal/common/: hal_assert.c hal_drivers.c
    ../../../../../Components/hal/include/: hal_assert.h hal_board.h hal_defs.h hal_drivers.h
  group HAL/Drivers
    ../../../../../Components/hal/include/: hal_adc.h hal_key.h hal_lcd.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
    ../../../../../Components/hal/target/MSP5438CC2520/: hal_aes.h
    ../../../../../Components/hal/target/MSP2618CC2520/: hal_ccm.h
  group HAL/Target/Config
    ../../../../../Components/hal/target/MSP5438CC2520/: hal_board_cfg.h hal_dco.c hal_dco.h hal_mac_cfg.c hal_mac_cfg.h hal_startup.c
  group HAL/Target/Drivers
    ../../../../../Components/hal/target/MSP5438CC2520/: hal_adc.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_timer.c hal_uart.c
  group HAL/Target/Includes
    ../../../../../Components/hal/target/MSP5438CC2520/: hal_mcu.h
    ../../../../../Components/hal/target/MSP430CC2520DB/: hal_types.h
  group MAC/High Level
    ../../../../../Components/mac/high_level/: mac_cfg.c mac_pib.c mac_pib.h mac_security_pib.c mac_security_pib.h
  group MAC/High Level/Lib
    ../../../Libraries/msp430/IAR/bin/Lib/: macLib_msp430.lib macLibSec_msp430.lib
  group MAC/Include
    ../../../../../Components/mac/include/: mac_api.h
  group MAC/Low Level/Common
    ../../../../../Components/mac/low_level/srf04/: mac_assert.h mac_autopend.c mac_autopend.h mac_backoff_timer.c mac_backoff_timer.h mac_low_level.c mac_low_level.h mac_radio.c mac_radio.h mac_rx.c mac_rx.h mac_rx_onoff.c mac_rx_onoff.h mac_sleep.c mac_sleep.h mac_tx.c mac_tx.h
  group MAC/Low Level/System
    ../../../../../Components/mac/low_level/srf04/dual_chip/: mac_dualchip.c mac_dualchip.h mac_dualchip_tx.c mac_dualchip_tx.h mac_mcu_timer.c mac_mcu_timer.h mac_radio_defs.c mac_radio_defs.h mac_spi.c mac_spi.h
  group OSAL
    ../../../../../Components/osal/common/: OSAL.c OSAL_Clock.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../../Components/osal/include/: OSAL_Custom.h
  group Services
    ../../../../../Components/services/saddr/: saddr.c saddr.h
  group Services/aes
    ../../../../../Components/services/aes/: zaesccm_api.h zaesccm_osal.c
