# IAR project msa_cc2530.ewp, settings and files
configuration Normal (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.CCDefines: CC2530EB; POWER_SAVING; HAL_AES=FALSE; HAL_DMA=FALSE; HAL_FLASH=FALSE; NON_BANKED; FEATURE_ENHANCED_BEACON; FEATURE_GREEN_POWER
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\..\common\CC2530; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\hal\target\CC2530EB; ..\..\..\..\..\Components\mac\include; ..\..\..\..\..\Components\mac\high_level; ..\..\..\..\..\Components\mac\low_level\srf04; ..\..\..\..\..\Components\mac\low_level\srf04\single_chip; ..\..\..\..\..\Components\mt; ..\..\..\..\..\Components\osal\include; ..\..\..\..\..\Components\services\saddr; ..\..\..\..\..\Components\services\sdata
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: ..\..\..\common\CC2530\ti_51ew_cc2530.xcl
configuration Secure (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: CC2530EB; POWER_SAVING; FEATURE_MAC_SECURITY; HAL_FLASH=FALSE; NON_BANKED; FEATURE_ENHANCED_BEACON; FEATURE_GREEN_POWER
  ICC8051.CCIncludePath2: ..\..\..\common\CC2530; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\hal\target\CC2530EB; ..\..\..\..\..\Components\mac\include; ..\..\..\..\..\Components\mac\high_level; ..\..\..\..\..\Components\mac\low_level\srf04; ..\..\..\..\..\Components\mac\low_level\srf04\single_chip; ..\..\..\..\..\Components\mt; ..\..\..\..\..\Components\osal\include; ..\..\..\..\..\Components\services\saddr; ..\..\..\..\..\Components\services\sdata; ..\..\..\..\..\Components\services\aes
configuration Normal-Banked (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: CC2530EB; POWER_SAVING; HAL_AES=FALSE; HAL_DMA=FALSE; HAL_FLASH=FALSE; FEATURE_ENHANCED_BEACON; FEATURE_GREEN_POWER
  XLINK.XclFile: ..\..\..\common\CC2530\ti_51ew_cc2530b.xcl
configuration Secure-Banked (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: CC2530EB; POWER_SAVING; FEATURE_MAC_SECURITY; HAL_FLASH=FALSE; FEATURE_ENHANCED_BEACON; FEATURE_GREEN_POWER
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2530F256_banked.xcl
configuration HB1x_R-RX (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: COORD_NODE; HAL_PA_LNA; CC2530EB; HAL_AES=FALSE; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_KEY=FALSE; HAL_UART=TRUE; FEATURE_ENHANCED_BEACON; FEATURE_GREEN_POWER; OSC32K_CRYSTAL_INSTALLED=FALSE
  ICC8051.CCIncludePath2: ..\..\Application; ..\..\Application\Serial; ..\..\..\common\CC2530; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\hal\target\CC2530EB; ..\..\..\..\..\Components\mac\include; ..\..\..\..\..\Components\mac\high_level; ..\..\..\..\..\Components\mac\low_level\srf04; ..\..\..\..\..\Components\mac\low_level\srf04\single_chip; ..\..\..\..\..\Components\mt; ..\..\..\..\..\Components\osal\include; ..\..\..\..\..\Components\services\saddr; ..\..\..\..\..\Components\services\sdata
  XLINK.XclFile: ..\..\..\common\CC2530\ti_51ew_cc2530b.xcl
configuration HB1x_E-TX (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: END_NODE; HAL_PA_LNA; CC2530EB; POWER_SAVING; HAL_AES=FALSE; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_KEY=FALSE; HAL_UART=TRUE; FEATURE_ENHANCED_BEACON; FEATURE_GREEN_POWER; OSC32K_CRYSTAL_INSTALLED=FALSE
  ICC8051.CCIncludePath2: as above
  XLINK.XclFile: ..\..\..\common\CC2530\ti_51ew_cc2530b.xcl
configuration HB1x_R-RX-S (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: COORD_NODE; HAL_PA_LNA; CC2530EB; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_KEY=FALSE; HAL_UART=TRUE; FEATURE_ENHANCED_BEACON; FEATURE_GREEN_POWER; FEATURE_MAC_SECURITY; OSC32K_CRYSTAL_INSTALLED=FALSE
  ICC8051.CCIncludePath2: as above
  XLINK.XclFile: ..\..\..\common\CC2530\ti_51ew_cc2530b.xcl
configuration HB1x_E-TX-S (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: END_NODE; HAL_PA_LNA; CC2530EB; POWER_SAVING; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_KEY=FALSE; HAL_UART=TRUE; FEATURE_ENHANCED_BEACON; FEATURE_GREEN_POWER; FEATURE_MAC_SECURITY; OSC32K_CRYSTAL_INSTALLED=FALSE
  ICC8051.CCIncludePath2: as above
  XLINK.XclFile: ..\..\..\common\CC2530\ti_51ew_cc2530b.xcl
  group Application
    ../../Application/: msa - test.c msa.c msa.h msa_Main.c msa_Osal.c Rf.h Serial.h
  group Application/Serial
    ../../Application/Serial/: SAps.c SAps.h SHal.c SHal.h SProtocol.c SProtocol.h
  group HAL/Common
    ../../../../../Components/hal/common/: hal_assert.c hal_drivers.c
    ../../../../../Components/hal/include/: hal_assert.h hal_defs.h hal_drivers.h
  group HAL/Drivers
    ../../../../../Components/hal/include/: hal_adc.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Target/CC2530EB/Config
    ../../../../../Components/hal/target/CC2530EB/: hal_board_cfg.h
  group HAL/Target/CC2530EB/Drivers
    ../../../../../Components/hal/target/CC2530EB/: hal_adc.c hal_dma.c hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2530EB/Includes
    ../../../../../Components/hal/target/CC2530EB/: hal_mcu.h hal_types.h
  group MAC/High Level
    ../../../../../Components/mac/high_level/: mac_cfg.c mac_high_level.h mac_pib.c mac_pib.h mac_security_pib.c mac_security_pib.h mac_spec.h
  group MAC/High Level/Lib
    ../../../Libraries/cc2530/IAR/bin/Lib/: macLib_cc2530-Banked.lib macLib_cc2530.lib macLibSec_cc2530-Banked.lib macLibSec_cc2530.lib
  group MAC/Include
    ../../../../../Components/mac/include/: mac_api.h
  group MAC/Low Level/Common
    ../../../../../Components/mac/low_level/srf04/: mac_assert.h mac_autopend.c mac_autopend.h mac_backoff_timer.c mac_backoff_timer.h mac_low_level.c mac_low_level.h mac_radio.c mac_radio.h mac_rx.c mac_rx.h mac_rx_onoff.c mac_rx_onoff.h mac_sleep.c mac_sleep.h mac_tx.c mac_tx.h
  group MAC/Low Level/System
    ../../../../../Components/mac/low_level/srf04/single_chip/: mac_csp_tx.c mac_csp_tx.h mac_mcu.c mac_mcu.h mac_mem.c mac_mem.h mac_radio_defs.c mac_radio_defs.h mac_rffrontend.c
  group OSAL
    ../../../../../Components/osal/common/: OSAL.c OSAL_Clock.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../../Components/osal/mcu/cc2530/: OSAL_Math.s51
  group Services
    ../../../../../Components/services/saddr/: saddr.c saddr.h
    ../../../../../Components/services/aes/: zaesccm_osal.c
