# IAR project msa_cc2538.ewp, settings and files
configuration Normal (ARM, debug)
  General.OGChipSelectEditMenu: CC2538SF53 TexasInstruments CC2538SF53
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; POWER_SAVING; CC2538_USE_ALTERNATE_INTERRUPT_MAP=1; FEATURE_GREEN_POWER; FEATURE_ENHANCED_BEACON; FEATURE_RESET_MACRO
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..\..\..\common\cc2538\; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\hal\target\CC2538; ..\..\..\..\..\Components\driverlib\cc2538\inc; ..\..\..\..\..\Components\driverlib\cc2538\source; ..\..\..\..\..\Components\sdriverlib\cc2538\source; ..\..\..\..\..\Components\bsp\srf06eb_cc2538\drivers\source; ..\..\..\..\..\Components\mac\include; ..\..\..\..\..\Components\mac\high_level; ..\..\..\..\..\Components\mac\low_level\srf05\single_chip; ..\..\..\..\..\Components\mac\low_level\srf05; ..\..\..\..\..\Components\osal\include; ..\..\..\..\..\Components\services\sdata; ..\..\..\..\..\Components\services\saddr
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: msa_cc2538.bin
  ILINK.IlinkOutputFile: msa_cc2538.out
  ILINK.IlinkIcfFile: ..\..\..\common\cc2538\cc2538.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\Components\driverlib\cc2538\bin\iar\sdriverlib.lib; ..\..\..\..\..\Components\bsp\srf06eb_cc2538\drivers\bin\iar\bsp.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Secure (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: CM2538SF53 TexasInstruments CM2538SF53
  ICCARM.CCDefines: ewarm; POWER_SAVING; CC2538_USE_ALTERNATE_INTERRUPT_MAP=1; FEATURE_MAC_SECURITY; FEATURE_GREEN_POWER; FEATURE_ENHANCED_BEACON; FEATURE_RESET_MACRO
  group Application
    ../../Application/: msa.c msa.h msa_Main.c msa_Osal.c
  group HAL/Common
    ../../../../../Components/hal/common/: hal_assert.c hal_drivers.c
  group HAL/Include
    ../../../../../Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_rpc.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Target/Config
    ../../../../../Components/hal/target/CC2538/: hal_board_cfg.h hal_mac_cfg.c hal_mac_cfg.h startup_ewarm.c
  group HAL/Target/Drivers
    ../../../../../Components/hal/target/CC2538/: hal_aes.c hal_ccm.c hal_ccm.h hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_sys_ctrl.c hal_systick.c hal_uart.c
  group HAL/Target/Includes
    ../../../../../Components/hal/target/CC2538/: hal_mcu.h hal_types.h
  group MAC/High Level
    ../../../../../Components/mac/high_level/: mac_cfg.c mac_pib.c mac_security_pib.c
  group MAC/High Level/Lib
    ../../../Libraries/cc2538/IAR/bin/Lib/: macLib_cc2538.a macLibSec_cc2538.a
  group MAC/Include
    ../../../../../Components/mac/include/: mac_api.h
  group MAC/Low Level/Common
    ../../../../../Components/mac/low_level/srf05/: hw_rfcore_sfr.h hw_rfcore_xreg.h mac_assert.h mac_autopend.c mac_autopend.h mac_backoff_timer.c mac_backoff_timer.h mac_low_level.c mac_low_level.h mac_radio.c mac_radio.h mac_rx.c mac_rx.h mac_rx_onoff.c mac_rx_onoff.h mac_sleep.c mac_sleep.h mac_tx.c mac_tx.h
  group MAC/Low Level/System
    ../../../../../Components/mac/low_level/srf05/single_chip/: mac_csp_tx.c mac_csp_tx.h mac_mcu.c mac_mcu.h mac_mem.c mac_mem.h mac_radio_defs.c mac_radio_defs.h mac_radio_reg_defs.h mac_rffrontend.c
  group OSAL/Common
    ../../../../../Components/osal/common/: OSAL.c OSAL_Clock.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
  group OSAL/include
    ../../../../../Components/osal/include/: comdef.h OSAL.h OSAL_Clock.h OSAL_Memory.h OSAL_PwrMgr.h OSAL_Tasks.h OSAL_Timers.h ZComDef.h
  group Services/saddr
    ../../../../../Components/services/saddr/: saddr.c saddr.h
  group Services/saddr/aes
    ../../../../../Components/services/aes/: zaesccm_api.h zaesccm_osal.c
  group Services/sdata
    ../../../../../Components/services/sdata/: sdata.h
