# IAR project msa_cc2531.ewp, settings and files
configuration HB1x_C (8051, debug)
  General.OGChipSelectMenu: CC2531F256 CC2531F256
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\Application; ..\..\Application\Serial; ..\..\Application\APP; ..\..\..\common\CC2530; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\hal\target\CC2530USB; ..\..\..\..\..\Components\hal\target\CC2530USB\usb\library; ..\..\..\..\..\Components\hal\target\CC2530USB\usb\library\cc2531; ..\..\..\..\..\Components\hal\target\CC2530USB\usb\class_cdc; ..\..\..\..\..\Components\mac\include; ..\..\..\..\..\Components\mac\high_level; ..\..\..\..\..\Components\mac\low_level\srf04; ..\..\..\..\..\Components\mac\low_level\srf04\single_chip; ..\..\..\..\..\Components\mt; ..\..\..\..\..\Components\osal\include; ..\..\..\..\..\Components\services\saddr; ..\..\..\..\..\Components\services\sdata; ..\..\..\..\..\Components\services\aes
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: ..\..\..\common\CC2530\ti_51ew_cc2531b.xcl
configuration HB1x_UC (8051, debug)
  as the first configuration, except:
configuration HB1x_L (8051, debug)
  as the first configuration, except:
  ICC8051.CCIncludePath2: ..\..\Application; ..\..\Application\Serial; ..\..\Application\APP; ..\..\Application\sEndBsp; ..\..\..\common\CC2530; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\hal\target\CC2530USB; ..\..\..\..\..\Components\hal\target\CC2530USB\usb\library; ..\..\..\..\..\Components\hal\target\CC2530USB\usb\library\cc2531; ..\..\..\..\..\Components\hal\target\CC2530USB\usb\class_cdc; ..\..\..\..\..\Components\mac\include; ..\..\..\..\..\Components\mac\high_level; ..\..\..\..\..\Components\mac\low_level\srf04; ..\..\..\..\..\Components\mac\low_level\srf04\single_chip; ..\..\..\..\..\Components\mt; ..\..\..\..\..\Components\osal\include; ..\..\..\..\..\Components\services\saddr; ..\..\..\..\..\Components\services\sdata; ..\..\..\..\..\Components\services\aes
configuration HB1x_J (8051, debug)
  as the first configuration, except:
  ICC8051.CCIncludePath2: ..\..\Application; ..\..\Application\Serial; ..\..\Application\APP; ..\..\Application\HB1S_J; ..\..\..\common\CC2530; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\hal\target\CC2530USB; ..\..\..\..\..\Components\hal\target\CC2530USB\usb\library; ..\..\..\..\..\Components\hal\target\CC2530USB\usb\library\cc2531; ..\..\..\..\..\Components\hal\target\CC2530USB\usb\class_cdc; ..\..\..\..\..\Components\mac\include; ..\..\..\..\..\Components\mac\high_level; ..\..\..\..\..\Components\mac\low_level\srf04; ..\..\..\..\..\Components\mac\low_level\srf04\single_chip; ..\..\..\..\..\Components\mt; ..\..\..\..\..\Components\osal\include; ..\..\..\..\..\Components\services\saddr; ..\..\..\..\..\Components\services\sdata; ..\..\..\..\..\Components\services\aes
configuration HB1S_W (8051, debug)
  as the first configuration, except:
  ICC8051.CCIncludePath2: as above
configuration HB1M_W (8051, debug)
  as the first configuration, except:
  ICC8051.CCIncludePath2: ..\..\Application; ..\..\Application\Serial; ..\..\Application\APP; ..\..\Application\mEndBsp; ..\..\..\common\CC2530; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\hal\target\CC2530USB; ..\..\..\..\..\Components\hal\target\CC2530USB\usb\library; ..\..\..\..\..\Components\hal\target\CC2530USB\usb\library\cc2531; ..\..\..\..\..\Components\hal\target\CC2530USB\usb\class_cdc; ..\..\..\..\..\Components\mac\include; ..\..\..\..\..\Components\mac\high_level; ..\..\..\..\..\Components\mac\low_level\srf04; ..\..\..\..\..\Components\mac\low_level\srf04\single_chip; ..\..\..\..\..\Components\mt; ..\..\..\..\..\Components\osal\include; ..\..\..\..\..\Components\services\saddr; ..\..\..\..\..\Components\services\sdata; ..\..\..\..\..\Components\services\aes
configuration HB1S_E (8051, debug)
  as the first configuration, except:
  ICC8051.CCIncludePath2: ..\..\Application; ..\..\Application\App; ..\..\Application\Serial; ..\..\..\common\CC2530; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\hal\target\CC2530USB; ..\..\..\..\..\Components\hal\target\CC2530USB\usb\library; ..\..\..\..\..\Components\hal\target\CC2530USB\usb\library\cc2531; ..\..\..\..\..\Components\hal\target\CC2530USB\usb\class_cdc; ..\..\..\..\..\Components\mac\include; ..\..\..\..\..\Components\mac\high_level; ..\..\..\..\..\Components\mac\low_level\srf04; ..\..\..\..\..\Components\mac\low_level\srf04\single_chip; ..\..\..\..\..\Components\mt; ..\..\..\..\..\Components\osal\include; ..\..\..\..\..\Components\services\saddr; ..\..\..\..\..\Components\services\sdata; ..\..\..\..\..\Components\services\aes
configuration HB1S_E-ZC (8051, debug)
  as the first configuration, except:
  ICC8051.CCIncludePath2: as above
configuration HB1L_E V1 (8051, debug)
  as the first configuration, except:
  ICC8051.CCIncludePath2: as above
configuration HB1M_E (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: xHAL_MAC_USE_REGISTER_POWER_VALUES
  ICC8051.CCIncludePath2: as above
configuration HB1X_E V1 (8051, debug)
  as the first configuration, except:
  ICC8051.CCIncludePath2: as above
configuration HB1A_E (8051, debug)
  as the first configuration, except:
  ICC8051.CCIncludePath2: as above
configuration HB1B_E (8051, debug)
  as the first configuration, except:
  ICC8051.CCIncludePath2: as above
configuration HB1D_E (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: xHAL_MAC_USE_REGISTER_POWER_VALUES
  ICC8051.CCIncludePath2: ..\..\Application; ..\..\Application\App; ..\..\Application\Serial; ..\..\Application\MFRC522; ..\..\..\common\CC2530; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\hal\target\CC2530USB; ..\..\..\..\..\Components\hal\target\CC2530USB\usb\library; ..\..\..\..\..\Components\hal\target\CC2530USB\usb\library\cc2531; ..\..\..\..\..\Components\hal\target\CC2530USB\usb\class_cdc; ..\..\..\..\..\Components\mac\include; ..\..\..\..\..\Components\mac\high_level; ..\..\..\..\..\Components\mac\low_level\srf04; ..\..\..\..\..\Components\mac\low_level\srf04\single_chip; ..\..\..\..\..\Components\mt; ..\..\..\..\..\Components\osal\include; ..\..\..\..\..\Components\services\saddr; ..\..\..\..\..\Components\services\sdata; ..\..\..\..\..\Components\services\aes
configuration HB1L_W (8051, debug)
  as the first configuration, except:
  ICC8051.CCIncludePath2: ..\..\Application; ..\..\Application\Serial; ..\..\Application\APP; ..\..\Application\lEndBsp; ..\..\Application\lEndBsp\SPI; ..\..\..\common\CC2530; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\hal\target\CC2530USB; ..\..\..\..\..\Components\hal\target\CC2530USB\usb\library; ..\..\..\..\..\Components\hal\target\CC2530USB\usb\library\cc2531; ..\..\..\..\..\Components\hal\target\CC2530USB\usb\class_cdc; ..\..\..\..\..\Components\mac\include; ..\..\..\..\..\Components\mac\high_level; ..\..\..\..\..\Components\mac\low_level\srf04; ..\..\..\..\..\Components\mac\low_level\srf04\single_chip; ..\..\..\..\..\Components\mt; ..\..\..\..\..\Components\osal\include; ..\..\..\..\..\Components\services\saddr; ..\..\..\..\..\Components\services\sdata; ..\..\..\..\..\Components\services\aes
configuration HB1E_E (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: xHAL_MAC_USE_REGISTER_POWER_VALUES
  ICC8051.CCIncludePath2: ..\..\Application\HB1E_E; ..\..\Application; ..\..\Application\App; ..\..\Application\Serial; ..\..\..\common\CC2530; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\hal\target\CC2530USB; ..\..\..\..\..\Components\hal\target\CC2530USB\usb\library; ..\..\..\..\..\Components\hal\target\CC2530USB\usb\library\cc2531; ..\..\..\..\..\Components\hal\target\CC2530USB\usb\class_cdc; ..\..\..\..\..\Components\mac\include; ..\..\..\..\..\Components\mac\high_level; ..\..\..\..\..\Components\mac\low_level\srf04; ..\..\..\..\..\Components\mac\low_level\srf04\single_chip; ..\..\..\..\..\Components\mt; ..\..\..\..\..\Components\osal\include; ..\..\..\..\..\Components\services\saddr; ..\..\..\..\..\Components\services\sdata; ..\..\..\..\..\Components\services\aes
  group Application/HB1L_W
    ../../Application/: HBL_W.c
  group Application/HB1L_W/lEndBsp
    ../../Application/lEndBsp/: bPower.c bPower.h eBsp.c eBsp.h Font.c Font.h hal_Rkey.c hal_Rkey.h Lcd.c Lcd.h Menu.c Menu.h MFRC522.c MFRC522.h Motor.c Motor.h
  group Application/HB1L_W/lEndBsp/SP1
    ../../Application/lEndBsp/SPI/: hal_SPI1.c hal_SPI1.h
  group Application/HB1x_C
    ../../Application/: HB1x_C.c
  group Application/HB1x_E
    ../../Application/: HB1A_E.c HB1B_E.c HB1L_E V2.c HB1L_E.c HB1M_E.c HB1S_E.c HB1X_E.c
  group Application/HB1x_E/HB1D_E
    ../../Application/HB1D_E/: hal_SPI1.c hal_SPI1.h MFRC522.c MFRC522.h
    ../../Application/: HB1D_E.c HB1D_E.h
  group Application/HB1x_E/HB1E_E
    ../../Application/HB1E_E/: hal_SPI1.c hal_SPI1.h MFRC522.c MFRC522.h
    ../../Application/: HB1E_E.c HB1E_E.h
  group Application/HB1x_J
    ../../Application/: HB1S_J.c
  group Application/HB1x_J/HB1S_J
    ../../Application/HB1S_J/: DigitalDis.c DigitalDis.h hal_Rkey.c hal_Rkey.h jBsp.c jBsp.h Menu.c Menu.h
  group Application/HB1x_L
    ../../Application/: HB1S_L.c
  group Application/HB1x_W
    ../../Application/: HB1x_W.c
  group Application/HB1x_W/HB1M_W/mEndBsp
    ../../Application/mEndBsp/: bPower.c bPower.h eBsp.c eBsp.h Font.c Font.h hal_Rkey.c hal_Rkey.h Lcd.c Lcd.h Menu.c Menu.h Motor.c Motor.h
  group Application/HB1x_W/HB1S_W/sEndBsp
    ../../Application/sEndBsp/: bPower.c bPower.h eBsp.c eBsp.h Font.c Font.h hal_Rkey.c hal_Rkey.h Lcd.c Lcd.h Menu.c Menu.h Motor.c Motor.h
  group Application/Pubilc
    ../../Application/: msa.h msa_Main.c msa_Osal.c RadioTxTest.c
    ../../../common/cc2530/: OnBoard.c
  group Application/Pubilc/APP
    ../../Application/APP/: Rf.c Rf.h Serial.c Serial.h
  group Application/Pubilc/Serial
    ../../Application/Serial/: SAps.c SAps.h SHal.c SHal.h SProtocol.c SProtocol.h
  group CFG
    ../../Application/CFG/: HB1A_E.cfg HB1B_E.cfg HB1D_E.cfg HB1E_E.cfg HB1L_E.cfg HB1L_W.cfg HB1M_E.cfg HB1M_W.cfg HB1S_E.cfg HB1S_E_ZC.cfg HB1S_W.cfg HB1x_C.cfg HB1X_E.cfg HB1x_J.cfg HB1x_L.cfg HB1x_UC.cfg HB1x_X.cfg
  group HAL/Common
    ../../../../../Components/hal/common/: hal_assert.c hal_drivers.c
  group HAL/Include
    ../../../../../Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_key.h hal_lcd.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Target/CC2530USB/Config
    ../../../../../Components/hal/target/CC2530USB/: hal_board_cfg.h
  group HAL/Target/CC2530USB/Drivers
    ../../../../../Components/hal/target/CC2530USB/: hal_adc.c hal_dma.c hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2530USB/Includes
    ../../../../../Components/hal/target/CC2530USB/: hal_mcu.h hal_types.h
  group HAL/Target/CC2530USB/USB/class_cdc
    ../../../../../Components/hal/target/CC2530USB/usb/class_cdc/: usb_cdc.h usb_cdc_descriptor.s51 usb_cdc_hooks.c usb_cdc_hooks.h usb_firmware_library_config.c usb_firmware_library_config.h usb_firmware_library_headers.h
  group HAL/Target/CC2530USB/USB/library
    ../../../../../Components/hal/target/CC2530USB/usb/library/: usb_descriptor.h usb_descriptor_parser.c usb_descriptor_parser.h usb_framework.c usb_framework.h usb_framework_structs.h usb_interrupt.h usb_reg.h usb_standard_requests.c usb_standard_requests.h usb_suspend.h
  group HAL/Target/CC2530USB/USB/library/cc2531
    ../../../../../Components/hal/target/CC2530USB/usb/library/cc2531/: usb_board_cfg.h usb_interrupt.c usb_suspend.c
  group MAC/High Level
    ../../../../../Components/mac/high_level/: mac_cfg.c mac_high_level.h mac_pib.c mac_pib.h mac_security_pib.c mac_security_pib.h mac_spec.h
  group MAC/High Level/Lib
    ../../../Libraries/cc2530/IAR/bin/Lib/: macLib_cc2530-Banked.lib macLibSec_cc2530-Banked.lib
  group MAC/Include
    ../../../../../Components/mac/include/: mac_api.h
  group MAC/Low Level/Common
    ../../../../../Components/mac/low_level/srf04/: mac_assert.h mac_autopend.c mac_autopend.h mac_backoff_timer.c mac_backoff_timer.h mac_low_level.c mac_low_level.h mac_radio.c mac_radio.h mac_rx.c mac_rx.h mac_rx_onoff.c mac_rx_onoff.h mac_sleep.c mac_sleep.h mac_tx.c mac_tx.h
  group MAC/Low Level/System
    ../../../../../Components/mac/low_level/srf04/single_chip/: mac_csp_tx.c mac_csp_tx.h mac_mcu.c mac_mcu.h mac_mem.c mac_mem.h mac_radio_defs.c mac_radio_defs.h mac_rffrontend.c
  group OSAL
    ../../../../../Components/osal/common/: OSAL.c OSAL_Clock.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../../Components/osal/mcu/cc2530/: OSAL_Math.s51 OSAL_Nv.c
  group ReadMe
    ../../../../../: 说明.txt
  group Services
    ../../../../../Components/services/saddr/: saddr.c saddr.h
    ../../../../../Components/services/aes/: zaesccm_api.h zaesccm_osal.c
